SRCREV ?= "176b2ab37994c360deb7ded7768ac6b4959e7a00"
SKELETON_URI ?= "git://github.com/madscientist159/skeleton"
