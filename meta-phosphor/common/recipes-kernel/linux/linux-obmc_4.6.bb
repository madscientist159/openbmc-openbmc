KBRANCH ?= "dev-4.6-firestone-fixes"
LINUX_VERSION ?= "4.6"
SRCREV="47e2db4f757d81b5df8edf3d1b58cba8361ed0b5"

require linux-obmc.inc
