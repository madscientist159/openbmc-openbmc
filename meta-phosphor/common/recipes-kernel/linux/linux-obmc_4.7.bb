KBRANCH ?= "dev-4.7-firestone-fixes"
LINUX_VERSION ?= "4.7"
SRCREV="582d3ca5dbc2280847962b1c0c55679a654b208a"

require linux-obmc.inc
