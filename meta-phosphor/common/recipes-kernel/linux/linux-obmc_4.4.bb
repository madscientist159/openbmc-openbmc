KBRANCH ?= "dev-4.4-firestone-fixes"
LINUX_VERSION ?= "4.4"
SRCREV="7948db98ed407e153b3b39546d5cb607d80c8947"

require linux-obmc.inc
